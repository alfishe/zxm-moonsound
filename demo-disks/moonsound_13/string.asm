;--------------------------------------------------------------------
; Описание: Бегущая строка
; Автор порта: Тарасов М.Н.(Mick),2016
;--------------------------------------------------------------------
Str_reload:
		ld	a,(Str_flg_end)
		and	a
		jr 	z,Str_init
		xor	a
		ld	(Str_flg_end),a
		scf
		ret
Str_init:
		ld	hl,Str_addr_text
		ld	(Str_addr_work),hl
		ret

Str_init_load:
		ld	hl,Str_addr_load
		ld	(Str_addr_work),hl
		ld	a,1
		ld	(Str_flg_end),a
		ld	a,(hl)
		ret	
Str_play:
		ld	a,(Str_count_bit)
		or	a
		call	z,Str_next_symol
		ret

Str_next_symol:
		ld	hl,(Str_addr_work)
		ld	a,(hl)
		and	a
		jr	z,Str_reload
		ret	c
		inc	hl
		ld	(Str_addr_work),hl
		sub	20h
		cp	60h
		jr	c, Str_load_data
		sub	60h
Str_load_data:
		ld	l, a
		ld	h, 0
		ld	de,Str_addr_font
		add	hl,hl
		add	hl,hl
		add	hl,hl
		add	hl,de
		ld	de,Str_symbol_buf
		ldi	
		ldi	
		ldi	
		ldi	
		ldi	
		ldi	
		ldi	
		ldi	
		ld	a,8
		ld	(Str_count_bit),a
		ret	

Str_update_symbol:
		ld	de, Str_symbol_buf
		ld	b,8
		ld	hl, 40F5h
loc_0_9BA8:
		ld	c,0
		ld	a,(de)
		rlca
		ld	(de),a
		jr	nc,loc_0_9C03
		inc	c		
loc_0_9C03:
		ld	a,0FEh
		and	(hl)
		or	c
		ld	(hl),a
		inc	h
		ld	a,h
		and	7
		jr	nz,loc_0_9BC2
		ld	a,l
		add	a,20h
		ld	l,a
		jr	c,loc_0_9BC2
		ld	a,h
		sub	8
		ld	h,a
loc_0_9BC2:
		inc	de
		djnz	loc_0_9BA8
		ld	a,(Str_count_bit)
		dec	a
		ld	(Str_count_bit),a
		ret

Str_draw_symbol:
		ld	hl,40F5h
		ld	b,8

Str_draw_line:
		push	hl
		and	a
		rl	(hl)
		dec	l
		rl	(hl)
		dec	l
		rl	(hl)
		dec	l
		rl	(hl)
		dec	l
		rl	(hl)
		dec	l
		rl	(hl)
		dec	l
		rl	(hl)
		dec	l
		rl	(hl)
		dec	l
		rl	(hl)
		dec	l
		rl	(hl)
		pop	hl
		inc	h
		ld	a,h
		and	7
		jr	nz,Str_next_line
		ld	a,l
		add	a,20h
		ld	l,a
		ld	c,a
		jr	c,Str_next_line
		ld	a,h
		sub	8
		ld	h,a
Str_next_line:
		djnz	Str_draw_line
		ret	

Str_symbol_buf:
		db 	0,0,0,0,0,0,0,0


Str_flg_end:
		db 	0

Str_count_bit:
		db 	0
Str_addr_work:
		dw 	0

Str_addr_load:
		db	'  *LOAD*  ',0
Str_addr_text:
		db 	'                << SPACE TO CHANGE MUSIC >>       '
		db 	'                ПРИВЕТ, ПРИВЕТ! MICK ШЛЕТ ВАМ ПЛАМЕННЫЙ ПРИВЕТ !'
		db	' СЕЙ ВЫПУСК ПРИУРОЧЕН К ПРЕДСТОЯЩЕЙ ВЫСТАВКЕ-ФЕСТИВАЛЮ CHAOS CONSTRUCTION 2016, КОТОРАЯ НАЧНЕТСЯ БУКВАЛЬНО ЗАВТРА'
		db	' 27 АВГУСТА. УВЫ В ЭТОТ РАЗ Я НЕ СМОГУ ЕЕ ПОСЕТИТЬ ПО ФИНАНСОВЫМ СООБРАЖЕНИЯМ, ПОЭТОМУ ПОКРИТИКОВАТЬ'
		db	' И ПОВОРЧАТЬ НЕ УДАСТЬСЯ ПО ПОВОДУ ДУШНОГО ЧЕРДАКА-КУРЯТНИКА, ГДЕ ПРОХОДИЛО МЕРОПРИЯТИЕ В ПРОШЛОМ ГОДУ.'
		db	' ВИДИМО НАРОДУ ПОНРАВИЛОСЬ ВЗБИРАТЬСЯ НА СЕЙ ЧЕРДАК ПО УЗКОЙ ЛЕСНКЕ, ЧТО РЕШИЛИ В ЭТОМ ГОДУ ПОВТОРИТЬ.'
		db	' АХ, В ЭТОМ ГОДУ МНЕ НЕ ПРИДЕСТЯ КАРАБКАТЬСЯ, А ЖАЛЬ. НУ ДА ЛАДНО, МОЖЕТ В СЛЕДУЮЩЕМ ГОДУ ВЫБЕРУСЬ.'
		db	' А ПОКАПРО СБОРНИК ДЛЯ КАРТОЧКИ ZXM-MOONSOUND. ОПЯТЬ КАРТИНКУ ПОДОГНАЛ AAA, Я ЕЕ ТОЛЬКО НЕМНОГО ПОПРАВИЛ ТАМ ГДЕ'
		db	' ВОЗНИКЛА В ЭТОМ НЕОБХОДИМОСТЬ. ОПЯТЬ ЖЕ AAA РАССКАЗАЛ ЧТО И КУДА НАДО РАЗМЕСТИТЬ. И ДА, ОН РЕШИЛ, ТАК СКАЗАТЬ'
		db	' КАПНУТЬ 40 ГРАДУСНОГО БАЛЬЗАМЧИКА НА ДУШУ RINDEX, МОЛ ПУСТЬ ШРИФТ БУДЕТ DIZZY. НУ ЛАДНО Я РЕШИЛ, ЧЕЙ ТО'
		db	' НЕ ВЫПИТЬ, ФУ ТЫ - КАПНУТЬ ТО НА ДУШУ :) КОРОЧЕ ТУТА DIZZY ШРИФТ. ТОЛЬКО ВОТ ЗАСАДА, ОН В НЕПОНЯТНОЙ БЫЛ'
		db	' КОДИРОВКИ, ПРИШЛОСЬ КОНВЕРТИТЬ. AAA, КАКОЙ ВЕК НА ДВОРЕ - СЕЙЧАС МОДНО ЛИБО В 866, ЛИБО В 1251 КОДИРОВКЕ ДЕЛАТЬ.'
		db	' А ТО В СЛЕДУЮЩИЙ РАЗ САМ ПИШИ ТЕКСТ ДЛЯ БЕГУЩЕЙ СТРОКИ. ФУУУУ, Я УЖЕ ПРИТОМИЛСЯ ИЗВЛЕКАТЬ ИЗ СВОЕЙ ПЛЮШЕВОЙ ГОЛОВЫ'
		db	' ВСЯКИЕ БУКВЫ И СЛОВА, ПОЖАЛУЙ ХВАТИТ НА ЭТОМ.'    

		db	' ИТАК, В ЭТОМ СБОРНИКЕ ДЕВЯТНАДЦАТЬ МЕЛОДИЙ, КОТОРЫЕ'
		db	' ПЕРЕКЛЮЧАЮТСЯ ПУТЕМ НАЖАТИЯ КЛАВИШИ "SPACE", ЛИБО ЖДЕТЕ ПОКА НЕ ЗАКОНЧИТСЯ МЕЛОДИЯ.'
		db	' СПИСОК МЕЛОДИЙ ИДЕТ СЛЕДОМ: '

		db	' BONE.MWM (GIVE THA DOG A BONE - MEITS 1995),'
		db	' CLODHOPP.MWM (ONE HELL OF AN INTRO - MEITS 1995),'
		db	' DRAAIKOE.MWM (DRAAIKOEKOEKSWLS - VALENCIA, ALLERHANDLE .F.J.W.KOLLER),'
		db	' FEED.MWM (GIVE ME MY FEED BACK!! - MEITS 1995),'
		db	' FRIK.MWM (FRIKANDEL SPECIAL - MEITS 1995),'
		db	' GRAGA.MWM (GRADIUS GAIDEN! - KONAMI MAN 1997),'
		db	' HAPPYJOY.MWM (HAPPY, HAPPY, JOY, JOY... - JELLE JELSMA 1996),'
		db	' HEAVY.MWM (HEAVY LATOK IN THE FOREST - MEITS 1995),'
		db	' INDIS.MWM (INDISPOSED PANCAKES - MEITS 1995),'
		db	' INTEXTRO.MWM (THE FINAL CHAPTER INTRO/EXTRO BGM - JELLE JELSMA),'
		db	' JJLJDG.MWM (J.J.L.J.D.G. - MEITS 1996),'
		db	' LAYDOCK.MWM (S-U-P-E-R LAYDOCK DEMO BGM - MEITS 1995),'
		db	' MOA.MWM (MOA-SOUND-A-LIKE - MEITS 1995),'	
		db	' PRELUDIA.MWM (PRELUDIA - VAN JOH. SEB. BACH BEWERKT:F.J.W. KOLLER),'	
		db	' SHIVAN.MWM (SHIVAN DRAGON (OPL4 CONVERSION) - JELLE JELSMA 1995),'	
		db	' SPAIN.MWM (MANUEL PAZOS),'	
		db	' PIPPOLS.MWM (ALWAYS PIPPOLS COVERS! - MEITS 1995),'	
		db	' POPTUNED.MWM (POPTUNED: MSX Radio - FRANS J.W.KOLLER),'	
		db	' SPAIN2.MWM (SPAIN - MANUEL PAZOS).'	
		

		db	' КРОМЕ ТОГО ЕСТЬ ЕЩЕ ОДНА КНОПКА "BREAK" - ВЫХОД В TR-DOS.'
		db 	' О ПРОГРАММЕ: ОСНОВНЫЕ МАТЕРИАЛЫ БЫЛИ ПОЗАИМСТВОВАНЫ С ПРОГРАММ КОМПЬЮТЕРА "MSX" И ВЕЛИКОЙ'
		db	' МУСОРКИ ПОД НАЗВАНИЕМ ИНТЕРНЕТ.' 
		db 	' ВСЕ ЭТО СОБИРАЛОСЬ НА РС ПРИ ПОМОЩИ АССЕМБЛЕРА  SJASMPLUS.'
		db	' НАПОМНЮ, ЕСЛИ У ВАС КАРТИНКИ, КОТОРЫЕ ХОТИТЕ ОПУБЛИКОВАТЬ ПОД МУЗЫКУ, ТО МИЛОСТИ ПРОСИМ В СЛЕДУЮЩИЙ ВЫПУСК.'
		db	' КОРОЧЕ, ЖДЕМ НОВЫХ ТВОРЕНИЙ ОТ ХУДОЖНИКОВ ПРОФЕССИОНАЛЬНЫХ И НЕ ОЧЕНЬ. ЗАСИМ ПРОСИМ ОТКЛАНЯТСЯ, ДАЛЕЕ ИДЕТ'
		db	' ТРАДИЦИОННАЯ РУБРИКА.'

		db	'             ПРИВЕТЫ И СПАСИБЫ!     '
		db	' ААА, TЕБЕ ВСЕ ТАКЖЕ ПРИВЕТ КАК ВЕЛИКОМУ БОХУ ДЕМОСЦЕНЫ :).'
		db	' TS-LABS, СПАСИБО ЗА ТО, ЧТО ПРИЮТИЛ НА СВОЕМ ФОРУМЕ БЕСХОЗНОГО ПЛЮШЕВОГО МЕДВЕДЯ.'
		db	' RINDEX, И ТЕБЕ ПРИВЕТ, DIZZY ШРИФТ СПЕШЛ ДЛЯ ТЕБЯ.'
		db	' МУЗЫКАНТАМ, СПАСИБО ЗА МУЗЫКУ, ЗВУЧАЩЕЙ В СБОРНИКЕ, ОГРОМНЫЙ РЕСПЕКТ И УВАЖУХА.'
		db	' ВСЕМ УЧАСТНИКАМ И ГОСТЯМ CC2016, ШЛЮ ПРИВЕТ. УВЫ, Я В ЭТОМ ГОДУ ПРОЛЕТАЮ.'
		db	' ВСЕМ ВЛАДЕЛЬЦАМ ПРОДУКЦИИ ПОД БРЕНДОМ "ZXM" БОЛЬШУЩИЙ ПРИВЕТ. ВАС МНОГО, МОЖНО НЕ БУДУ ВАС НАЗЫВАТЬ ВСЕХ ПОИМЕННО.'
		db	' ПРИВЕТ ТАКЖЕ ВСЕМ СПЕКТРУМИСТАМ, БЫВШИМ, НАСТОЯЩИМ И ВОЗМОЖНО БУДУЩИМ.'
		db	'       И ПОСЛЕДНИЙ АБЗАЦ :) :)'
		db	' ВСЯ ИНФА ПО МОИМ ПРОЕКТАМ НА САЙТЕ WWW.MICKLAB.RU, '
		db	' СВЯЗАТЬСЯ СО МНОЙ МОЖНО ЧЕРЕЗ ФОРУМ WWW.TS-LABS.INFO - НИКНЕЙМ MICK ИЛИ ЧЕРЕЗ МЫЛО'
		db	' MICKLAB(ГАВ-ГАВ)MAIL.RU.' 
		db	' ПОРА ПРОЩАТЬСЯ. ПОСМОРТИМ БУДУТ ЛИ ЕЩЕ ПРОГРАММКИ ОТ МЕНЯ :) ПОКА! ПОКА!      '
		db	'            AUGUST *2016*    GRAPHICS AAA AND CODE BY MICK         '
		db	'                                             ',0           		
Str_addr_font:
		incbin "diz_w.fnt"

;		.end
