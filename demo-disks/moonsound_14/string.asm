;--------------------------------------------------------------------
; Описание: Бегущая строка
; Автор порта: Тарасов М.Н.(Mick),2016
;--------------------------------------------------------------------
Str_reload:
		ld	a,(Str_flg_end)
		and	a
		jr 	z,Str_init
		xor	a
		ld	(Str_flg_end),a
		scf
		ret
Str_init:
		ld	hl,Str_addr_text
		ld	(Str_addr_work),hl
		ret

Str_init_load:
		ld	hl,Str_addr_load
		ld	(Str_addr_work),hl
		ld	a,1
		ld	(Str_flg_end),a
		ld	a,(hl)
		ret	
Str_play:
		ld	a,(Str_count_bit)
		or	a
		call	z,Str_next_symol
		ret

Str_next_symol:
		ld	hl,(Str_addr_work)
		ld	a,(hl)
		and	a
		jr	z,Str_reload
		ret	c
		inc	hl
		ld	(Str_addr_work),hl
		sub	20h
		cp	60h
		jr	c, Str_load_data
		sub	60h
Str_load_data:
		ld	l, a
		ld	h, 0
		ld	de,Str_addr_font
		add	hl,hl
		add	hl,hl
		add	hl,hl
		add	hl,de
		ld	de,Str_symbol_buf
		ldi	
		ldi	
		ldi	
		ldi	
		ldi	
		ldi	
		ldi	
		ldi	
		ld	a,8
		ld	(Str_count_bit),a
		ret	

Str_update_symbol:
		ld	de, Str_symbol_buf
		ld	b,8
		ld	hl, 50F5h
loc_0_9BA8:
		ld	c,0
		ld	a,(de)
		rlca
		ld	(de),a
		jr	nc,loc_0_9C03
		inc	c		
loc_0_9C03:
		ld	a,0FEh
		and	(hl)
		or	c
		ld	(hl),a
		inc	h
		ld	a,h
		and	7
		jr	nz,loc_0_9BC2
		ld	a,l
		add	a,20h
		ld	l,a
		jr	c,loc_0_9BC2
		ld	a,h
		sub	8
		ld	h,a
loc_0_9BC2:
		inc	de
		djnz	loc_0_9BA8
		ld	a,(Str_count_bit)
		dec	a
		ld	(Str_count_bit),a
		ret

Str_draw_symbol:
		ld	hl,50F5h
		ld	b,8

Str_draw_line:
		push	hl
		and	a
		rl	(hl)
		dec	l
		rl	(hl)
		dec	l
		rl	(hl)
		dec	l
		rl	(hl)
		dec	l
		rl	(hl)
		dec	l
		rl	(hl)
		dec	l
		rl	(hl)
		dec	l
		rl	(hl)
		dec	l
		rl	(hl)
		dec	l
		rl	(hl)
		dec	l
		rl	(hl)
		dec	l
		rl	(hl)
		pop	hl
		inc	h
		ld	a,h
		and	7
		jr	nz,Str_next_line
		ld	a,l
		add	a,20h
		ld	l,a
		ld	c,a
		jr	c,Str_next_line
		ld	a,h
		sub	8
		ld	h,a
Str_next_line:
		djnz	Str_draw_line
		ret	

Str_symbol_buf:
		db 	0,0,0,0,0,0,0,0


Str_flg_end:
		db 	0

Str_count_bit:
		db 	0
Str_addr_work:
		dw 	0

Str_addr_load:
		db	'  *LOAD*    ',0
Str_addr_text:
		db 	'                << SPACE TO CHANGE MUSIC >>       '
		db 	'                ПРИВЕТ, ПРИВЕТ! MICK СНОВА ПРИВЕТСТВУЕТ ВАС!'
		db	' ПРЕДСТАВЛЯЮ НА ВАШ СУД НОВЫЙ СБОРНИК С МУЗЫКОЙ В ПОДДЕРЖКУ СВОЕЙ ЗВУКОВОЙ КАРТЫ'
		db	' ZXM-MOONSOUND. ЭТОТ ВЫПУСК ПРИУРОЧЕН К БУРЖУЙСКОМУ ПРАЗДНИКУ, ИМЕНУЕМЫМ КАК HALLOWEN.'
		db	' СООТВЕТСТВЕННО И ТЕМАТИКА СБОРНИКА СООТВЕТСТВУЮЩАЯ - ЛУНА, ЗЛОБНЫЕ ТЫКВЫ И ДУШЕРАЗДИРАЮЩАЯ МУЗЫКА.'
		db	' КАРТИНКУ КАК ОБЫЧНО НАШЕЛ В ИНЕТЕ И ИЗВРАТИЛ  ДО НЕУЗНАВАЕМОСТИ, НЕ НУ А ЧЕ ВЫ ХОТЕЛИ'            
		db	' ОТ РУКОЖОПОГО ХУДОЖНИКА. ФОНТ ВЗЯЛ ИЗ ПРЕДЫДУЩЕГО СБОРНИКА, ИБО ЛЕНИВО ЧТО ТО БЫЛО ИСКАТЬ ДРУГОЙ.'
		db	' ЗА МУЗЫКАЛЬНОЕ СОПРОВОЖДЕНИЕ ОТВЕЧАЕТ МУЗЫКАНТ NEAR DARK,  МЕЛОДИИ ВЗЯТЫ ИЗ СБОРНИКА  ALTO С'
		db	' КОМПЬЮТЕРА MSX 2. НУ А В ОСТАЛЬНОМ ВСЕ КЛАССИЧЕСКИ - АНАЛИЗАТОРЫ, МЕРЦАЮЩИЕ ТЫКВЫ.'
		db	' В МИРЕ СПЕКТРУМА ПОКА НАБЛЮДАЕТСЯ НЕКОЕ ЗАТИШЬЕ. МАРИЯ БРАХМАТУЛЛИНА ЧТО ТО УСПОКОИЛАСЬ И ПЕРЕСТАЛА'
		db	' ВЕСТИ БЕСКОНЕЧНУЮ ВОЙНУ С АДЕПТАМИ ХАЙПА. ЗАТО К НЕЙ НАВЕДАЛСЯ НОМЕРНОЙ ВИТЕК, СОЗДАТЕЛЬ ВУНДЕРВАФЛЕЙ,'
		db 	' ПРАВДА В БОЛЬШЕЙ СТЕПЕНИ ТЕОРЕТИЧЕСКИХ. И СОБСТВЕННО В СВОЕМ РЕПЕРТУАРЕ ВСЕ ДЕЛАТЬ С НУЛЯ - СОБРАЛСЯ КОРОЧЕ'
		db	' С НУЛЯ НАПИСАТЬ ДЕМУ. ААА, ОСТОРОЖНЕЕ, С НУЛЯ ОНО У НЕГО И НА НУЛЕ ОСТАЕТСЯ. ВИТЕК МОЖЕТ ТЕБЯ ЗАКИДАТЬ'
		db	' САМОСТИРАЮЩИМИСЯ ПОСТАМИ, А НЕ ДЕМАМИ. ТАК ЧТО СЛЕДИ ЗА НИМ ВНИМАТЕЛЬНЕЕ, А ЛУЧШЕ УМЕРТВИ ЖИВОТИНКУ'
		db	' ПОКА НЕ ПОЗДНО, ТЕМ БОЛЕЕ ОНО САМЫЙ РАЗ В HALLOWEEN ПОЙДЕТ.    '  

		db	' ИТАК, В ЭТОМ СБОРНИКЕ ДВЕНАДЦАТЬ МЕЛОДИЙ, КОТОРЫЕ'
		db	' ПЕРЕКЛЮЧАЮТСЯ ПУТЕМ НАЖАТИЯ КЛАВИШИ "SPACE", ЛИБО ЖДЕТЕ ПОКА НЕ ЗАКОНЧИТСЯ МЕЛОДИЯ.'
		db	' СПИСОК МЕЛОДИЙ ИДЕТ СЛЕДОМ: '

		db	' AMAZED.MWM (AMAZED (THE OFFSPRING) - NEAR DARK 1997),'
		db	' BONUS_1.MWM (ELEANOR (THE GATHERING) - ALTO BONUS #1 -  NEAR DARK 1996),'
		db	' BONUS_2.MWM (THE MIRROR WATERS (THE GATHERING) - ALTO BONUS #2 -  NEAR DARK 1996),'
		db	' CLOSEFAR.MWM (CLOSE, BUT FAR AWAY - NEAR DARK 1997),'
		db	' DARKNESS.MWM (DARKNESS - NEAR DARK 1997),'
		db	' DROWNED.MWM (DROWNED MAID (AMORPHIS) - NEAR DARK 1997),'
		db	' EMPTYNES.MWM (COMPLETE EMPTYNESS - NEAR DARK 1997),'
		db	' FOLKNORT.MWM (FOLK OF THE NORTH (AMORPHIS) - NEAR DARK 1997),'
		db	' GONEAWAY.MWM (GONE AWAY (THE OFFSPRING) - NEAR DARK 1997),'
		db	' MONSUNP2.MWM (PART OF MOON AND SUN PART II (AMORPHIS) - NEAR DARK 1997),'
		db	' LOVE_JO.MWM (LOVE JO TO DEATH (TYPE OF NEGATIVE) - NEAR DARK 1997),'
		db	' SELECTOR.MWM (GRAVEYARD (THE FUCK-ERROR) - - NEAR DARK 1997).'

		db	' КРОМЕ ТОГО ЕСТЬ ЕЩЕ ОДНА КНОПКА "BREAK" - ВЫХОД В TR-DOS.'
		db 	' О ПРОГРАММЕ: ОСНОВНЫЕ МАТЕРИАЛЫ БЫЛИ ПОЗАИМСТВОВАНЫ С ПРОГРАММ КОМПЬЮТЕРА "MSX" И ВЕЛИКОЙ'
		db	' МУСОРКИ ПОД НАЗВАНИЕМ ИНТЕРНЕТ.' 
		db 	' ВСЕ ЭТО СОБИРАЛОСЬ НА РС ПРИ ПОМОЩИ АССЕМБЛЕРА  SJASMPLUS.'
		db	' НАПОМНЮ, ЕСЛИ У ВАС КАРТИНКИ, КОТОРЫЕ ХОТИТЕ ОПУБЛИКОВАТЬ ПОД МУЗЫКУ, ТО МИЛОСТИ ПРОСИМ В СЛЕДУЮЩИЙ ВЫПУСК.'
		db	' КОРОЧЕ, ЖДЕМ НОВЫХ ТВОРЕНИЙ ОТ ХУДОЖНИКОВ ПРОФЕССИОНАЛЬНЫХ И НЕ ОЧЕНЬ. ЗАСИМ ПРОСИМ ОТКЛАНЯТСЯ, ДАЛЕЕ ИДЕТ'
		db	' ТРАДИЦИОННАЯ РУБРИКА.'

		db	'             ПРИВЕТЫ И СПАСИБЫ!     '
		db	' ААА, TЕБЕ ВСЕ ТАКЖЕ ПРИВЕТ КАК ВЕЛИКОМУ БОХУ ДЕМОСЦЕНЫ :). ПРИБЕЙ НОМЕРНОГО ВИТЬКА ПОКА НЕ ПОЗДНО.'
		db	' ОДИН ФИГ С НУЛЯ ОНО И В АФРИКЕ С НУЛЯ. '
		db	' TS-LABS, СПАСИБО ЗА ТО, ЧТО ПРИЮТИЛ НА СВОЕМ ФОРУМЕ БЕСХОЗНОГО ПЛЮШЕВОГО МЕДВЕДЯ.'
		db	' NEAR DARK, СПАСИБО ЗА МУЗЫКУ, ЗВУЧАЩЕЙ В СБОРНИКЕ, ОГРОМНЫЙ РЕСПЕКТ И УВАЖУХА.'
		db	' ВСЕМ ВЛАДЕЛЬЦАМ ПРОДУКЦИИ ПОД БРЕНДОМ "ZXM" БОЛЬШУЩИЙ ПРИВЕТ. ВАС МНОГО, МОЖНО НЕ БУДУ ВАС НАЗЫВАТЬ ВСЕХ ПОИМЕННО.'
		db	' ПРИВЕТ ТАКЖЕ ВСЕМ СПЕКТРУМИСТАМ, БЫВШИМ, НАСТОЯЩИМ И ВОЗМОЖНО БУДУЩИМ.'
		db	'       И ПОСЛЕДНИЙ АБЗАЦ :) :)'
		db	' ВСЯ ИНФА ПО МОИМ ПРОЕКТАМ НА САЙТЕ WWW.MICKLAB.RU, '
		db	' СВЯЗАТЬСЯ СО МНОЙ МОЖНО ЧЕРЕЗ ФОРУМ WWW.TS-LABS.INFO - НИКНЕЙМ MICK ИЛИ ЧЕРЕЗ МЫЛО'
		db	' MICKLAB(ГАВ-ГАВ)MAIL.RU.' 
		db	' ПОРА ПРОЩАТЬСЯ. ПОСМОРТИМ БУДУТ ЛИ ЕЩЕ ПРОГРАММКИ ОТ МЕНЯ :) ПОКА! ПОКА!      '
		db	'            OKTOBER *2016*    GRAPHICS AND CODE BY MICK         '
		db	'                                             ',0           		
Str_addr_font:
		incbin "diz_w.fnt"

;		.end
